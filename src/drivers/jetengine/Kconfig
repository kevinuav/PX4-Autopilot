## src/drivers/jetengine/Kconfig
```kconfig
menuconfig DRIVERS_JETENGINE
	bool "jetengine"
	default n
	---help---
		Enable support for jetengine
```
